/*
 * test_lineframe.c - 八路巡线模块串口帧解析的 PC 单测
 *
 * 这份测试的重点不是"正常帧能解开"（那太容易），而是**这个协议没有校验和**，
 * 所以"结构校验"是唯一能挡住误码的东西。误码进控制环的后果是车猛拐一下 ——
 * 因此下面一半以上的断言都是**反例**：畸形/串位/越界/半截帧必须被拒。
 *
 * 帧格式真源: 厂家 PDF `0.8路巡线模块的使用方法` 第 3 节（资料在仓库内
 *   workbench/天猛星主板平台/资料/八路巡线红外传感器/）。极性 0=在黑线上。
 */
#include <stdio.h>
#include <string.h>
#include "lineframe.h"

static int g_fail = 0;
static void ck(const char *what, int ok)
{
    if (!ok) g_fail++;
    printf("  [%s] %s\n", ok ? "PASS" : "FAIL", what);
}
static int feed(lf_t *L, const char *s, uint32_t t)
{
    int frames = 0;
    for (const char *p = s; *p; p++) frames += lf_push(L, *p, t);
    return frames;
}

int main(void)
{
    lf_t L;

    printf("test_lineframe (无校验和 => 结构校验是唯一防线):\n");

    /* ---- (1) 正常数字帧 ---- */
    lf_init(&L);
    ck("数字帧被接受", feed(&L, "$D,x1:0,x2:1,x3:0,x4:1,x5:0,x6:1,x7:0,x8:1#", 100) == 1);
    {
        int d[8];
        ck("数字值取得到且新鲜", lf_get_digital(&L, 100, 200, d) == 1);
        ck("数字值逐位正确(0=在黑线上)",
           d[0]==0 && d[1]==1 && d[2]==0 && d[3]==1 && d[4]==0 && d[5]==1 && d[6]==0 && d[7]==1);
        ck("此时还没有模拟值", lf_get_analog(&L, 100, 200, d) == 0);
        ck("状态 = LF_OK", lf_status(&L, 100, 200) == LF_OK);
    }

    /* ---- (2) 正常模拟帧 + 边界值 ---- */
    lf_init(&L);
    ck("模拟帧被接受(含边界 0 与 4096)",
       feed(&L, "$A,x1:0,x2:4096,x3:1,x4:2048,x5:100,x6:200,x7:300,x8:400#", 50) == 1);
    {
        int a[8];
        ck("模拟值取得到", lf_get_analog(&L, 50, 200, a) == 1);
        ck("模拟值正确", a[0]==0 && a[1]==4096 && a[3]==2048 && a[7]==400);
    }

    /* ---- (3) ⭐ 新鲜度：过期数据绝不冒充有效 ---- */
    lf_init(&L);
    feed(&L, "$D,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#", 1000);
    {
        int d[8];
        ck("刚收到 -> 有效", lf_get_digital(&L, 1000, 200, d) == 1);
        ck("199ms 后仍有效",  lf_get_digital(&L, 1199, 200, d) == 1);
        ck("201ms 后判过期(**这条防的是模块掉线后车按旧偏差一直拐**)",
           lf_get_digital(&L, 1201, 200, d) == 0);
        ck("状态 = LF_STALE", lf_status(&L, 1201, 200) == LF_STALE);
    }
    /* 从未收到 => NO_DATA（和 STALE 必须分开：一个查接线, 一个查模块掉没掉） */
    lf_init(&L);
    ck("从未收到 -> LF_NO_DATA", lf_status(&L, 500, 200) == LF_NO_DATA);

    /* ---- (4) ⭐ 反例：必须被拒的畸形帧 ---- */
    struct { const char *s; const char *why; } bad[] = {
        { "$D,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0#",            "只有 7 组" },
        { "$D,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0,x9:0#",  "多了第 9 组" },
        { "$D,x1:0,x3:0,x2:0,x4:0,x5:0,x6:0,x7:0,x8:0#",       "**通道顺序串位**(x3 出现在 x2 位置)" },
        { "$D,x1:2,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#",       "数字型出现非 0/1 的值" },
        { "$A,x1:4097,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#",    "模拟值越界(>4096)" },
        { "$X,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#",       "未知帧类型 X" },
        { "$D x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#",       "类型后缺逗号" },
        { "$D,x1:,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#",        "冒号后没有数字" },
        { "$D,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0 #",      "末尾有多余字符" },
        { "$D,y1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#",       "标签不是 x" },
    };
    for (unsigned i = 0; i < sizeof(bad)/sizeof(bad[0]); i++) {
        lf_init(&L);
        int n = feed(&L, bad[i].s, 10);
        char msg[160];
        snprintf(msg, sizeof msg, "拒: %s", bad[i].why);
        ck(msg, n == 0 && L.n_bad == 1);
    }

    /* ---- (5) ⭐ 半截帧后紧跟好帧：'$' 必须无条件重新开始 ----
     * 真机上这一定会发生: 我们是在模块已经在发的中途才开始接收的。 */
    lf_init(&L);
    ck("半截帧(从中间接入)后, 下一帧仍能解开",
       feed(&L, "x5:0,x6:1,x7:0,x8:1#$D,x1:1,x2:1,x3:1,x4:0,x5:0,x6:1,x7:1,x8:1#", 20) == 1);
    {
        int d[8];
        lf_get_digital(&L, 20, 200, d);
        ck("解开的是**后**那一帧(x4/x5 压线)", d[3]==0 && d[4]==0 && d[0]==1);
    }
    /* 帧内又来一个 '$'（上一帧丢了 '#'）=> 丢弃前半, 用新的 */
    lf_init(&L);
    ck("帧内再遇 '$' -> 丢前半用新帧",
       feed(&L, "$D,x1:0,x2:0$D,x1:1,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#", 30) == 1);

    /* ---- (6) 溢出保护：一直不来 '#' 不许写爆缓冲 ---- */
    lf_init(&L);
    {
        char junk[LF_BUF * 3];
        junk[0] = '$';
        for (unsigned i = 1; i < sizeof(junk) - 1; i++) junk[i] = 'x';
        junk[sizeof(junk) - 1] = 0;
        feed(&L, junk, 40);
        ck("超长无 '#' -> 计 n_ovf 且不崩", L.n_ovf >= 1);
        /* 溢出之后仍要能恢复 */
        ck("溢出后仍能解开下一帧",
           feed(&L, "$D,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#", 41) == 1);
    }

    /* ---- (7) 交替收到 D 与 A（`$0,1,1#` 下的真实情况），两者各自独立计时 ---- */
    lf_init(&L);
    feed(&L, "$D,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#", 100);
    feed(&L, "$A,x1:9,x2:9,x3:9,x4:9,x5:9,x6:9,x7:9,x8:9#", 150);
    ck("D/A 计数各自为 1", L.n_dig == 1 && L.n_ana == 1);
    {
        int t[8];
        /* t=350: D 龄 250 已过期; A 龄 200 恰好在界内 ⇒ 两者独立计时、互不顶替。
         * （首版这条断言取 t=250 是我自己算错: 那时 D 龄才 150ms，本来就该是新鲜的。） */
        ck("A 新鲜时 D 已过期(独立计时, 不互相顶替)",
           lf_get_analog(&L, 350, 200, t) == 1 && lf_get_digital(&L, 350, 200, t) == 0);
    }
    ck("全程无误判为 bad", L.n_bad == 0);

    /* ---- (8) '\r\n' 容忍（串口助手/模块可能带行尾） ---- */
    lf_init(&L);
    ck("带 CRLF 也能解开",
       feed(&L, "$D,x1:0,x2:0,x3:0,x4:0,x5:0,x6:0,x7:0,x8:0#\r\n", 60) == 1);

    printf(g_fail ? "==== %d FAILED ====\n" : "==== ALL PASS ====\n", g_fail);
    return g_fail ? 1 : 0;
}
